# Keil uVision project LED_Control.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED_Control +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c include: .\APP;.\HAL\btn;.\HAL\led;.\LIB;.\MCAL\gpio;.\MCAL\systick
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group MCAL
    ./MCAL/gpio/: gpio_interface.h gpio_private.h gpio_program.c
    ./MCAL/systick/: systick_interface.h systick_private.h systick_program.c systick_linking_config.c systick_linking_config.h
  group HAL
    ./HAL/led/: led_interface.h led_program.c
    ./HAL/btn/: btn_interface.h btn_program.c
  group LIB
    ./LIB/: std.h bit_math.h
  group APP
    ./APP/: app.c app.h
  group MAIN
    ./: main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
